# Keil uVision project Project.uvproj, settings and files
target MusicPlayer (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Core
    ./: main.c delay.c lcd1602.c matrixKey.c buzzer.c notes.c timer0.c
  group Songs
    ./songs/: qingtian.c qinghuaci.c yequ_short.c
